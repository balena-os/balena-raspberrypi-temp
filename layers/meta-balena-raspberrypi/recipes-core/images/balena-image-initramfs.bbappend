IMAGE_ROOTFS_MAXSIZE:raspberrypi5 = "40960"
